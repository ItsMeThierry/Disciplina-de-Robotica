Commit message: Reorganizacao

File: pratica_02/urdf/vasco_robot.urdf (robot description, URDF)
Before this commit: robot vasco_robot, 8 links, 7 joints
Links:
- link base_link: geometry collision box size=0.4 0.2 0.1; visual box size=0.4 0.2 0.1
